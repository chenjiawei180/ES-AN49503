# Keil uVision project ES-AN49503.uvprojx, settings and files
target ES-AN49503 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKE06Z128xxx4 NXP
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: IRAM(0x1FFFF000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ES-AN49503 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CMSIS CPU_KE06 KEIL FRDM_KE06 VECTOR=0x5000
  c include: ..\common;..\cpu\headers;..\cpu;..\drivers;..\user
  asm define: RAM_TARGET
  library: MicroLIB
  memory RVCT4: ROM 0x5000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  group common
    ../common/: alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ../cpu/: arm_cm0.c start.c sysinit.c systick.c vectors.c startup_MKE06Z4.s
  group driver
    ../drivers/: acmp.c adc.c crc.c flash.c ftm.c gpio.c i2c.c ics.c kbi.c mscan.c pit.c pmc.c pwt.c rtc.c sim.c spi.c uart.c wdog.c
  group user
    ../user/: led.c wdt.c spi_app.c crc.c eeprom_24c.c sleep.c mscan_api.c main.c can_app.c
